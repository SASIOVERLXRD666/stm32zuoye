# Keil uVision project duorenwu.uvprojx, settings and files
target duorenwu (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: duorenwu +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;.\uC-BSP;.\uC-CONFIG;.\uC-CPU;.\uC-LIB;.\uCOS-III;.\uC-CPU\ARM-Cortex-M3\RealView;.\uCOS-III\Source;.\uCOS-III\Ports;.\uC-CPU\ARM-Cortex-M3\GNU;.\uC-CPU\ARM-Cortex-M3\IAR;.\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\uC-LIB\Ports\ARM-Cortex-M3\GNU;.\uCOS-III\Ports\ARM-Cortex-M3\Generic;.\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group cpu
    ./uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
    ./uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
  group lib
    ./uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group port
    ./uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group source
    ./uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group config
    ./uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group bsp
    ./uC-BSP/: bsp.c bsp.h
software components: CMSIS:CORE 4.3.0
